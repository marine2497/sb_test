# Keil uVision project Unman_Ship2022.uvprojx, settings and files
target Unman_Shop2022 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Unman_Ship2022
  AfterMake: fromelf --bin !L --output  ./bin/SUV_Board.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: .\App\Inc;.\StLIb\STM32F10x_StdPeriph_Driver\inc;.\StLIb\STM32F10x_StdPeriph_Driver;.\StLIb\CMSIS\Core\CM3;.\ShipContrl\Inc;.\Bsp\gnss;.\Bsp\gnss;.\Bsp\parser;.\Bsp\periph;.\Bsp\math;.\Bsp\output
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./App/Sur/: main.c base_ship.c ship.c TargetCtrl.c water_ship.c Global.c DGPS.c
  group prasher
    ./Bsp/parser/: bestxyza.c gpgga.c gpgsv.c gphdt.c gphpd.c gphpr.c gprmc.c gptra.c headinga.c parser.c ppnav.c ppnfo.c refstation.c string-split.c test.c
  group Bsp
    ./ShipContrl/Sur/: bsp.c com.c security.c time.c water_sensor.c
    ./Bsp/periph/: nvic.c gpio.c retarget.c uart.c uart1.c uart2.c uart3.c aux_lib.c
    ./Bsp/parser/: getline.c
  group Ship_conrtol
    ./ShipContrl/Sur/: prompt.c
  group StLib
    ./StLIb/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_exti.c
  group Starts
    ./StLIb/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
